Commit message: Changed car9 to car2

File: cartographer_ros/cartographer_ros/urdf/f110.urdf (robot description, URDF)
Before this commit: robot f110, 5 links, 4 joints
Links:
- removed link car_9_laser
- added link car_2_laser
Joints:
- joint lidar_joint: child car_9_laser -> car_2_laser
